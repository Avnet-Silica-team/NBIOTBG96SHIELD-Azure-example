# Keil uVision project Project.uvprojx, settings and files
target Azure_Sns (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F401RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.11.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x18000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Azure_Sns +hex
  AfterMake: $K\ARM\ARMCC\bin\fromelf.exe --bin --output=@L.bin !L
  c flags: Optim=2 OneElfS=1 uC99=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO,STM32_NUCLEO,NO_LOGGING=1,EINVAL=-1,ENOMEM=EINVAL,USE_GENERICACCESSKEY_IOTHUB=0,DONT_USE_UPLOADTOBLOB,REFCOUNT_ATOMIC_DONTCARE,USE_MBED_TLS,MBEDTLS_CONFIG_FILE=<mbedtls_config.h>
  c misc: --gnu --no_conditionalize
  c include: ..\..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\..\..\..\..\..\Drivers\BSP\Components\Common;..\..\..\..\..\..\Drivers\CMSIS\Include;..\..\..\..\..\..\Drivers\BSP\Components\hts221;..\..\..\..\..\..\Drivers\BSP\Components\lis3mdl;..\..\..\..\..\..\Drivers\BSP\Components\lps22hb;..\..\..\..\..\..\Drivers\BSP\Components\lps25hb;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds0;..\..\..\..\..\..\Drivers\BSP\Components\lsm6ds3;..\..\..\..\..\..\Drivers\BSP\Components\lsm6dsl;..\..\..\..\..\..\Drivers\BSP\Components\lsm303agr;..\..\..\..\..\..\Drivers\BSP\Components\M24SR;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A2;..\..\..\..\..\..\Drivers\BSP\X_NUCLEO_IKS01A1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-NFC01A1;..\..\..\..\..\..\Drivers\BSP\X-NUCLEO-IDW01M1;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\umqtt\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\iothub_client\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\c-utility\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\serializer\inc;..\..\..\..\..\..\Middlewares\Third_Parties\Azure-IoT-SDK-C\parson;..\..\..\..\..\..\Middlewares\ST\lib_NDEF\inc;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Utils;..\..\..\..\..\..\Middlewares\ST\STM32_SPWF01SA\Inc;..\..\..\..\..\..\Middlewares\ST\STM32_MetaDataManager;..\..\..\..\..\..\Middlewares\Third_Parties\mbedtls\include;..\..\..\..\..\..\Middlewares\Third_Parties\BG96;..\..\..\..\..\..\Drivers\BSP\BG96_IoT_Shield;..\..\..\..\..\..\Middlewares\Third_Parties\BG96\Parser
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group User
    ../../Src/: stm32f4xx_it.c main.c console.c stm32f4xx_hal_msp.c HWAdvanceFeatures.c agenttime_STM32Cube.c AzureClient_mqtt_TM.c socketio_STM32Cube.c STM32CubeRTCInterface.c tcpsocketSTM32Cube.c tickcounter_STM32Cube.c timingSystem.c TLocalBuffer.c platform_STM32Cube_NucleoF401RE.c azure_base64.c azure_sha1.c tlsio_mbedtls_STM32Cube_Nucleo.c
    ../../../../../../Utilities/RegistrationAgentInternal/: RegistrationAgentInternal.c
  group Drivers/CMSIS
    ../../Src/: system_stm32f4xx.c
  group Drivers/BSP/Components
    ../../../../../../Drivers/BSP/Components/hts221/: HTS221_Driver.c HTS221_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lis3mdl/: LIS3MDL_MAG_driver.c LIS3MDL_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps22hb/: LPS22HB_Driver.c LPS22HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lps25hb/: LPS25HB_Driver.c LPS25HB_Driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds0/: LSM6DS0_ACC_GYRO_driver.c LSM6DS0_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6ds3/: LSM6DS3_ACC_GYRO_driver.c LSM6DS3_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm303agr/: LSM303AGR_ACC_driver.c LSM303AGR_ACC_driver_HL.c LSM303AGR_MAG_driver.c LSM303AGR_MAG_driver_HL.c
    ../../../../../../Drivers/BSP/Components/lsm6dsl/: LSM6DSL_ACC_GYRO_driver.c LSM6DSL_ACC_GYRO_driver_HL.c
    ../../../../../../Drivers/BSP/Components/M24SR/: lib_M24SR.c m24sr.c
  group Drivers/BSP/X-NUCLEO-IKS01A1
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A1/: x_nucleo_iks01a1_magneto.c x_nucleo_iks01a1_pressure.c x_nucleo_iks01a1.c x_nucleo_iks01a1_accelero.c x_nucleo_iks01a1_gyro.c x_nucleo_iks01a1_humidity.c x_nucleo_iks01a1_temperature.c
  group Drivers/BSP/X-NUCLEO-IKS01A2
    ../../../../../../Drivers/BSP/X_NUCLEO_IKS01A2/: x_nucleo_iks01a2.c x_nucleo_iks01a2_accelero.c x_nucleo_iks01a2_gyro.c x_nucleo_iks01a2_humidity.c x_nucleo_iks01a2_magneto.c x_nucleo_iks01a2_pressure.c x_nucleo_iks01a2_temperature.c
  group Middlewares/STM32_MetaDataManager
    ../../../../../../Middlewares/ST/STM32_MetaDataManager/: MetaDataManager.c
  group Keil
    ./: startup_stm32f401xe.s
  group Drivers/STM32F4xx-Nucleo
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_dma.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c
  group Drivers/BSP/STM32F401RE_NUCLEO
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_I2C.c stm32f4xx_nucleo.c stm32f4xx_UART.c
  group Drivers/BSP/X-NUCLEO-NFC01A1
    ../../../../../../Drivers/BSP/X-NUCLEO-NFC01A1/: drv_I2C_M24SR.c
  group Middlewares/libNDEF
    ../../../../../../Middlewares/ST/lib_NDEF/src/: lib_NDEF.c lib_NDEF_AAR.c lib_NDEF_Email.c lib_NDEF_Geo.c lib_NDEF_MyApp.c lib_NDEF_SMS.c lib_NDEF_Text.c lib_NDEF_URI.c lib_NDEF_Vcard.c lib_NDEF_Wifi.c lib_TagType4.c
  group Middlewares/mbedTLS
    ../../../../../../Middlewares/Third_Parties/mbedtls/library/: aes.c aesni.c asn1parse.c bignum.c cipher.c cipher_wrap.c ctr_drbg.c debug.c ecdh.c ecp.c ecp_curves.c entropy.c gcm.c md.c md_wrap.c oid.c pem.c pk.c pk_wrap.c pkparse.c platform.c rsa.c sha256.c sha512.c ssl_ciphersuites.c ssl_cli.c ssl_tls.c x509.c x509_crt.c base64.c sha1.c
  group Middlewares/AzureIOT
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/c-utility/src/: buffer.c constbuffer.c constmap.c crt_abstractions.c doublylinkedlist.c hmac.c hmacsha256.c map.c optionhandler.c sastoken.c sha224.c sha384-512.c singlylinkedlist.c string_tokenizer.c strings.c urlencode.c usha.c vector.c xio.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/iothub_client/src/: iothub_client_authorization.c iothub_client_ll.c iothub_message.c iothubtransport_mqtt_common.c iothubtransportmqtt.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/parson/: parson.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/serializer/src/: agenttypesystem.c codefirst.c commanddecoder.c datamarshaller.c datapublisher.c iotdevice.c jsondecoder.c jsonencoder.c methodreturn.c multitree.c schema.c schemalib.c
    ../../../../../../Middlewares/Third_Parties/Azure-IoT-SDK-C/umqtt/src/: mqtt_client.c mqtt_codec.c mqtt_message.c
  group Middlewares/BG96
    ../../../../../../Middlewares/Third_Parties/BG96/: BG96_interface.c
  group Drivers/BSP/BG96_Iot_Shield
    ../../../../../../Drivers/BSP/BG96_IoT_Shield/: stm32_BG96_iot.c
software components: CMSIS:CORE 5.0.0
